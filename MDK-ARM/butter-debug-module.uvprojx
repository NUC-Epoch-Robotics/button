# Keil uVision project butter-debug-module.uvprojx, settings and files
target butter-debug-module (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: butter-debug-module +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../bsp/bsp_spi;../Applications;../Modules;../bsp/bsp_iic;../bsp/bsp_usart;../bsp/self_def_massage;../Modules/Buzzer;../Modules/KEY;./DebugConfig;../Modules/self_def_massage;../Modules/Ring_buffer;../Modules/OLED;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../easylogger/inc;../easylogger/src;../letter_shell
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep shellCommand*
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c crc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_crc.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application
    ../Applications/: button_motor.c button_motor.h
  group Modules
    ../Modules/KEY/: KEY.c KEY.h multi_button.c multi_button.h
    ../Modules/Buzzer/: Buzzer.c Buzzer.h
    ../Modules/OLED/: OLED_IIC_Config.c OLED_IIC_Config.h OLED_Function.c OLED_Function.h OLED_Front.h
    ../Modules/Ring_buffer/: ring_buffer.c ring_buffer.h
    ../Modules/self_def_massage/: self_def_message.c self_def_massage.h
  group Bsp
    ../bsp/bsp_iic/: bsp_iic.c bsp_iic.h
    ../bsp/bsp_spi/: bsp_spi.c bsp_spi.h
    ../bsp/bsp_usart/: bsp_usart.c bsp_usart.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group EasyLogger
    ../easylogger/src/: elog.c elog_utils.c
    ../easylogger/inc/: elog.h elog_cfg.h
    ../easylogger/port/: elog_port.c
  group shell
    ../letter_shell/: shell.c shell.h shell_cfg.h shell_cmd_list.c shell_companion.c shell_ext.c shell_ext.h shell_port.c shell_port.h
software components: CMSIS:CORE 4.3.0
